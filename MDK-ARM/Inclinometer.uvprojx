# Keil uVision project Inclinometer.uvprojx, settings and files
target Inclinometer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Inclinometer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\RS485Connector;..\Modbus;..\Memory;..\AdjustmentMathematics;..\UniversalProtocol;..\TimeSpan;..\LSM9DS0
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group RS485Connector
    ../RS485Connector/: RS485Connector.h RS485Connector.c
  group Modbus
    ../Modbus/: ModbusCommon.h ModbusCommon.c
  group Memory
    ../Memory/: Memory.h Memory.c
  group AdjustmentMathematics
    ../AdjustmentMathematics/: AdjustmentMathematics.h
  group UniversalProtocol
    ../UniversalProtocol/: UPCommon.h UPCommon.c DebugCellFormat.h DebugCellFormat.c DebugCell.h DebugCell.c
  group TimeSpan
    ../TimeSpan/: TimeSpan.h TimeSpan.c
  group LSM9DS0
    ../LSM9DS0/: LSM9DS0.c LSM9DS0.h
software components: CMSIS:CORE 4.3.0
